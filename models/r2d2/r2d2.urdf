Commit message: fine tune camera

File: models/r2d2/r2d2.urdf (robot description, URDF)
Before this commit: robot physics, 17 links, 16 joints
Joints:
- joint tocamera: origin xyz=0 0.1 0 -> xyz=0 0.18 0.15
